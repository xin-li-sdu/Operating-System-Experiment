# Keil uVision project lab.uvproj, settings and files
target template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: template
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\include;.\src\ucos_ii\src;.\src\ucos_ii\port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./src/: system_stm32f10x.c
    ./: startup_stm32f10x_md.s
  group user
    ./: main.c user_asm.s user_c.c
    ./src/: stm32f10x_it.c
  group libstm32
    ./src/: misc.c stm32f10x_flash.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_exti.c
  group ucos ii
    ./src/ucos_ii/port/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
    ./src/ucos_ii/src/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
    ./include/: os_cfg.h
